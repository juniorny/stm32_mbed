# Keil uVision project Nucleo_blink_led.uvprojx, settings and files
target Nucleo_blink_led (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Nucleo_blink_led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=2
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 __ASSERT_MSG TARGET_STM32F0 CMSIS_VECTAB_VIRTUAL_HEADER_FILE=\"cmsis_nvic.h\" DEVICE_PORTINOUT=1 TARGET_FF_MORPHO DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO TARGET_LIKE_CORTEX_M0 CMSIS_VECTAB_VIRTUAL MBED_BUILD_TIMESTAMP=1544015786.24 DEVICE_PORTOUT=1 DEVICE_STDIO_MESSAGES=1 TARGET_RELEASE DEVICE_SERIAL_FC=1 DEVICE_INTERRUPTIN=1 ARM_MATH_CM0 DEVICE_ANALOGIN=1 TARGET_CORTEX_M DEVICE_I2C=1 TARGET_CORTEX TARGET_STM TOOLCHAIN_ARM __CORTEX_M0 TOOLCHAIN_ARM_STD DEVICE_PWMOUT=1 TARGET_LIKE_MBED TARGET_FAMILY_STM32 DEVICE_SPI=1 __MBED__=1 DEVICE_SPISLAVE=1 TARGET_STM32F030R8 DEVICE_PORTIN=1 DEVICE_SERIAL=1 TARGET_M0 DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM TARGET_NUCLEO_F030R8
  c misc: --no_rtti --split_sections -c --cpu=Cortex-M0 --apcs=interwork --no_depend_system_headers --md --gnu --preinclude=mbed_config.h
  c include: ..;..\user;..\mbed;..\mbed/drivers;..\mbed/platform;..\mbed/hal;..\mbed\hal\mpu;..\mbed\hal\storage_abstraction;..\mbed\hal\TARGET_FLASH_CMSIS_ALGO;..\mbed\targets\TARGET_STM;..\mbed\targets\TARGET_STM\TARGET_STM32F0;..\mbed\targets\TARGET_STM\TARGET_STM32F0\device;..\mbed\targets\TARGET_STM\TARGET_STM32F0\TARGET_NUCLEO_F030R8;..\mbed\targets\TARGET_STM\TARGET_STM32F0\TARGET_NUCLEO_F030R8\device;..\mbed\cmsis\TARGET_CORTEX_M
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DCMSIS_VECTAB_VIRTUAL,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-DCMSIS_VECTAB_VIRTUAL_HEADER_FILE="cmsis_nvic.h",-D__CMSIS_RTOS
  asm include: .\mbed;..\user;.\mbed\drivers;.\mbed\hal;.\mbed\hal\mpu;.\mbed\hal\storage_abstraction;.\mbed\hal\TARGET_FLASH_CMSIS_ALGO;.\mbed\platform;.\mbed\TARGET_NUCLEO_F030R8;.\mbed\TARGET_NUCLEO_F030R8\device;.\mbed\cmsis;.\mbed\cmsis\TARGET_CORTEX_M
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\mbed\targets\TARGET_STM\TARGET_STM32F0\TARGET_NUCLEO_F030R8\device\TOOLCHAIN_ARM_STD\stm32f0xx.sct
  link misc: --show_full_path
  group user
    ../user/: main.cpp mbed_config.h
  group mbed
    ../mbed/: mbed.h
    ../mbed/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.cpp QSPI.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    ../mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.cpp LowPowerTickerWrapper.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_lp_ticker_wrapper.h mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    ../mbed/hal/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    ../mbed/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    ../mbed/hal/TARGET_FLASH_CMSIS_ALGO/: flash_data.h
    ../mbed/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_crash_data_offsets.h mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_error_hist.c mbed_error_hist.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_mpu_mgmt.c mbed_mpu_mgmt.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h CThunk.h
    ../mbed/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_overrides.c i2c_api.c lp_ticker.c mbed_crc_api.c mbed_overrides.c mbed_rtx.h nvic_addr.h PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c qspi_api.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm_spi_api.c stm32_assert.h trng_api.c us_ticker.c
    ../mbed/targets/TARGET_STM/TARGET_STM32F0/: analogin_device.c analogout_device.c can_device.h common_objects.h device.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h
    ../mbed/targets/TARGET_STM/TARGET_STM32F0/device/: stm32_hal_legacy.h stm32f0xx_hal.c stm32f0xx_hal.h stm32f0xx_hal_adc.c stm32f0xx_hal_adc.h stm32f0xx_hal_adc_ex.c stm32f0xx_hal_adc_ex.h stm32f0xx_hal_can.c stm32f0xx_hal_can.h stm32f0xx_hal_cec.c stm32f0xx_hal_cec.h stm32f0xx_hal_comp.c stm32f0xx_hal_comp.h stm32f0xx_hal_conf.h stm32f0xx_hal_cortex.c stm32f0xx_hal_cortex.h stm32f0xx_hal_crc.c stm32f0xx_hal_crc.h stm32f0xx_hal_crc_ex.c stm32f0xx_hal_crc_ex.h stm32f0xx_hal_dac.c stm32f0xx_hal_dac.h stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dac_ex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.c stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.c stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.c stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.c stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_i2s.c stm32f0xx_hal_i2s.h stm32f0xx_hal_irda.c stm32f0xx_hal_irda.h stm32f0xx_hal_irda_ex.h stm32f0xx_hal_iwdg.c stm32f0xx_hal_iwdg.h stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd.h stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pcd_ex.h stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc.h stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_rtc_ex.h stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard.h stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smartcard_ex.h stm32f0xx_hal_smbus.c stm32f0xx_hal_smbus.h stm32f0xx_hal_spi.c stm32f0xx_hal_spi.h stm32f0xx_hal_spi_ex.c stm32f0xx_hal_spi_ex.h stm32f0xx_hal_tim.c stm32f0xx_hal_tim.h stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tim_ex.h stm32f0xx_hal_tsc.c stm32f0xx_hal_tsc.h stm32f0xx_hal_uart.c stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart_ex.h stm32f0xx_hal_usart.c stm32f0xx_hal_usart.h stm32f0xx_hal_usart_ex.h stm32f0xx_hal_wwdg.c stm32f0xx_hal_wwdg.h stm32f0xx_ll_adc.c stm32f0xx_ll_adc.h stm32f0xx_ll_bus.h stm32f0xx_ll_comp.c stm32f0xx_ll_comp.h stm32f0xx_ll_cortex.h stm32f0xx_ll_crc.c stm32f0xx_ll_crc.h stm32f0xx_ll_crs.c stm32f0xx_ll_crs.h stm32f0xx_ll_dac.c stm32f0xx_ll_dac.h stm32f0xx_ll_dma.c stm32f0xx_ll_dma.h stm32f0xx_ll_exti.c stm32f0xx_ll_exti.h stm32f0xx_ll_gpio.c stm32f0xx_ll_gpio.h stm32f0xx_ll_i2c.c stm32f0xx_ll_i2c.h stm32f0xx_ll_iwdg.h stm32f0xx_ll_pwr.c stm32f0xx_ll_pwr.h stm32f0xx_ll_rcc.c stm32f0xx_ll_rcc.h stm32f0xx_ll_rtc.c stm32f0xx_ll_rtc.h stm32f0xx_ll_spi.c stm32f0xx_ll_spi.h stm32f0xx_ll_system.h stm32f0xx_ll_tim.c stm32f0xx_ll_tim.h stm32f0xx_ll_usart.c stm32f0xx_ll_usart.h stm32f0xx_ll_utils.c stm32f0xx_ll_utils.h stm32f0xx_ll_wwdg.h system_stm32f0xx.c
    ../mbed/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F030R8/: objects.h PeripheralNames.h PeripheralPins.c PinNames.h
    ../mbed/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F030R8/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h stm32f0xx.h stm32f030x8.h system_clock.c system_stm32f0xx.h us_ticker_data.h
    ../mbed/targets/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F030R8/device/TOOLCHAIN_ARM_STD/: startup_stm32f030x8.S
    ../mbed/cmsis/TARGET_CORTEX_M/: core_cm0.h
